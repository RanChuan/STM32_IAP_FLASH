# Keil uVision project IAP_FLASH.uvprojx, settings and files
target IAP_FLASH (ARM-ADS)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IAP_FLASH +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\app\CMD;..\app\CRC;..\HARDWARE\MALLOC;..\HARDWARE\STMFLASH;..\HARDWARE\W25QXX;..\libraries\inc;..\startup;..\system\sys;..\user;..\system\delay
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000004 size 0x2000
  group USER
    ../user/: main.c stm32f10x_it.c
  group STARTUP
    ../startup/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group STM32_LIB
    ../libraries/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c
  group SYSTEM
    ../system/sys/: sys.c
    ../system/delay/: delay.c
  group HARDWARE
    ../HARDWARE/MALLOC/: malloc.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/W25QXX/: flash.c
  group APP
    ../app/CRC/: crc8_16.c
  group README
    ../: ReadMe.txt
